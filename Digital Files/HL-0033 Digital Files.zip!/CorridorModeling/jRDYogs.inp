STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.0000000000
VPI 4 S 2475.0000000000 E 350.5127499999 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.7277499999 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1575.0000000000 E 348.1126447308 L 100.0000000000
VPI 3 S 1750.0000000000 E 349.9337472941 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6500000000 L 80.0000000000
VPI 5 S 2105.0000000000 E 352.9825000000 L 130.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y2
VPI 1 S 1200.0000000000 E 351.7096893615
VPI 2 S 1675.0000000000 E 348.6929000292 L 100.0041457609
VPI 3 S 1805.0000000000 E 347.2625323007 L 150.0000000000
VPI 4 S 2100.0000000000 E 348.1500000000 L 250.0000000000
VPI 5 S 2515.0000000000 E 360.0501989547 L 370.0000000000
VPI 6 S 2700.0000000000 E 356.4611989547
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.0000000000
VPI 4 S 2475.0000000000 E 350.5127499999 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.7277499999 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
