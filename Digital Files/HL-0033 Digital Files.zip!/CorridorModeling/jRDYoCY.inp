STORE PROFILE Y1
VPI 1 S 1620.0000000000 E 347.7939142805
VPI 2 S 1675.0000000000 E 348.5089142805 L 100.0000000000
VPI 3 S 2005.0000000000 E 351.3413700000 L 80.0000000000
VPI 4 S 2175.0000000000 E 352.8713700000 L 160.0000000000
VPI 5 S 2545.0000000000 E 350.2100000000 L 100.0000000000
VPI 6 S 2615.0000000000 E 350.0000000000
END PROFILE
STORE PROFILE Y2RA
VPI 1 S 1030.0000000000 E 989.1949571016
VPI 2 S 1145.0000000000 E 990.3568000000 L 50.0000000000
VPI 3 S 1171.8400000001 E 989.8200000000
END PROFILE
STORE PROFILE L
VPI 1 S 1540.0000000000 E 339.5995630546
VPI 2 S 1900.0000000000 E 328.0795630547 L 700.0000000000
VPI 3 S 2455.0000000000 E 350.7706375635 L 350.0000000000
VPI 4 S 3280.0000000000 E 355.3218818642 L 300.0000000000
VPI 5 S 3599.1399999999 E 346.8827383303
VPI 6 S 3625.4654774801 E 347.1845929733
END PROFILE
STORE PROFILE Y1
VPI 1 S 1000.0000000000 E 347.1821424588
VPI 2 S 1444.1299999999 E 352.4228764588
END PROFILE
STORE PROFILE Y1
VPI 1 S 1000.0000000000 E 347.1821424588
VPI 2 S 1444.1299999999 E 352.4228764588
END PROFILE
STORE PROFILE L
VPI 1 S 1540.0000000000 E 339.5995630546
VPI 2 S 1900.0000000000 E 328.0795630547 L 700.0000000000
VPI 3 S 2455.0000000000 E 350.7706375635 L 350.0000000000
VPI 4 S 3250.0000000000 E 356.1151835689 L 350.0000000000
VPI 5 S 3599.1399999999 E 346.8827383303
VPI 6 S 3625.4654774801 E 347.1845929733
END PROFILE
STORE PROFILE Y1
VPI 1 S 1000.0000000000 E 347.1821424588
VPI 2 S 1325.0000000000 E 351.2165250000 L 100.0000000000
VPI 3 S 1444.1299999999 E 352.1100000000
VPI 4 S 1536.1299999999 E 352.8000000000
VPI 5 S 1585.0000000000 E 353.1665250000 L 79.1649573815
VPI 6 S 1950.0000000000 E 350.1412114850 L 100.0000000000
VPI 7 S 2000.0000000000 E 350.3073664717
END PROFILE
STORE PROFILE Y2
VPI 1 S 1200.0000000000 E 351.5903414736
VPI 2 S 1860.0000000000 E 347.2767093443 L 150.0000000000
VPI 3 S 2100.0000000000 E 348.1107039173 L 250.0000000000
VPI 4 S 2400.0000000000 E 356.6881995504 L 200.0000000000
VPI 5 S 2502.6780582627 E 357.3252647481
END PROFILE
STORE PROFILE Y2
VPI 1 S 1200.0000000000 E 351.5903414736
VPI 2 S 1680.0000000000 E 348.4531544705 L 100.0000000000
VPI 3 S 1795.0000000000 E 347.3725764256 L 130.0000000000
VPI 4 S 2110.0000000000 E 348.3966204384 L 300.0000000000
VPI 5 S 2400.0000000000 E 356.6881995504 L 199.9999999994
VPI 6 S 2502.6780582627 E 357.3252647481
END PROFILE
STORE PROFILE L
VPI 1 S 1540.0000000000 E 339.5995630546
VPI 2 S 1900.0000000000 E 328.0795630547 L 700.0000000000
VPI 3 S 2455.0000000000 E 350.7706375635 L 350.0000000000
VPI 4 S 3220.0000000000 E 355.8885095496 L 350.0000000000
VPI 5 S 3625.4654774801 E 347.7792000000
END PROFILE
STORE PROFILE L
VPI 1 S 1540.0000000000 E 338.7662579485
VPI 2 S 1900.0000000000 E 327.2462579485 L 720.0000000000
VPI 3 S 2455.0000000000 E 350.7706375635 L 365.3680640127
VPI 4 S 3220.0000000000 E 355.8885095496 L 350.0000000000
VPI 5 S 3625.4654774801 E 347.7792000000
END PROFILE
STORE PROFILE L
VPI 1 S 1540.0000000000 E 338.7662579485
VPI 2 S 1900.0000000000 E 327.2462579485 L 720.0000000000
VPI 3 S 2455.0000000000 E 350.7706375635 L 350.0000000000
VPI 4 S 3220.0000000000 E 355.8885095496 L 350.0000000000
VPI 5 S 3625.4654774801 E 347.7792000000
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323731853
VPI 2 S 1510.0000000000 E 339.2806496750 L 300.0000000000
VPI 3 S 2035.0000000000 E 332.9683586871 L 530.0000000000
VPI 4 S 2455.0000000000 E 350.7706329876 L 300.0000000000
VPI 5 S 3220.0000000000 E 355.8885095496 L 350.0000784388
VPI 6 S 3625.4654774801 E 347.7792000000
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323731853
VPI 2 S 1545.0000000000 E 337.5885808560 L 370.0000000000
VPI 3 S 2090.0000000000 E 334.8635808560 L 420.0000000000
VPI 4 S 2475.0000000000 E 350.9044336820 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.8885095496 L 350.0000784387
VPI 6 S 3625.4654774801 E 347.7792000000
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323731853
VPI 2 S 1545.0000000000 E 337.5885808560 L 370.0000000000
VPI 3 S 2090.0000000000 E 334.8635808560 L 420.0000000000
VPI 4 S 2475.0000000000 E 350.9044336820 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.8885095496 L 350.0000784387
VPI 6 S 3625.4654774801 E 347.7792000000
END PROFILE
STORE PROFILE Y22RPDFLY
VPI 1 S 1000.0000000000 E 204.1500000000
VPI 2 S 1210.0000000000 E 201.5838000000 L 350.0000000001
VPI 3 S 1675.0000000000 E 203.1312688698 L 450.0000000000
VPI 4 S 4250.0000000000 E 282.5045825214 L 750.0000000000
VPI 5 S 5310.0000000000 E 267.6175034303 L 550.0000000000
VPI 6 S 5609.3197957641 E 274.2674023963
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000000000
VPI 3 S 2090.0000000000 E 334.8635762800 L 420.0000000000
VPI 4 S 2475.0000000000 E 350.9044291061 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.8885049737 L 350.0000000000
VPI 6 S 3625.4654804545 E 347.7791049737
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1825.0000000000 E 351.2165240822 L 100.0000000000
VPI 3 S 2085.0000000000 E 353.1665240822 L 80.0000000000
VPI 4 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 5 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1825.0000000000 E 351.2165240822 L 100.0000000000
VPI 3 S 2085.0000000000 E 353.1665240822 L 80.0000000000
VPI 4 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 5 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y2
VPI 1 S 1200.0000000000 E 351.7096858225
VPI 2 S 1680.0000000000 E 348.4531581218 L 100.0000000000
VPI 3 S 1795.0000000000 E 347.3725800770 L 130.0000000000
VPI 4 S 2110.0000000000 E 348.3966240898 L 300.0000000000
VPI 5 S 2515.0000000000 E 360.0501953033 L 370.0000000000
VPI 6 S 2700.0000000000 E 356.4611953033
END PROFILE
STORE PROFILE Y_SOUTH
VPI 1 S 1025.0000000000 E 329.7535737257
VPI 2 S 1040.0000000000 E 329.8890096871 L 30.0000000003
VPI 3 S 1090.0000000000 E 331.6833587643 L 60.0000000000
VPI 4 S 1155.0000000000 E 336.2209166599 L 50.0000000000
VPI 5 S 1196.3999999999 E 335.3929166599
END PROFILE
STORE PROFILE Y_NORTH
VPI 1 S 1279.3999999999 E 333.9484165998
VPI 2 S 1295.0000000000 E 334.2604165998 L 30.0000000000
VPI 3 S 1335.0000000000 E 336.7489124125 L 30.0000000000
VPI 4 S 1350.0000000000 E 336.7939124125
END PROFILE
STORE PROFILE Y_NORTH
VPI 1 S 1279.3999999999 E 333.9484165998
VPI 2 S 1295.0000000000 E 334.2604165998 L 30.0000000000
VPI 3 S 1335.0000000000 E 336.7489124125 L 30.0000000000
VPI 4 S 1350.0000000000 E 336.7939124125
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000000000
VPI 3 S 2089.9999886954 E 334.8635758091 L 449.9999976248
VPI 4 S 2475.0000000000 E 350.9044291061 L 309.9999999998
VPI 5 S 3220.0000000000 E 355.8885049737 L 350.0000000000
VPI 6 S 3625.4654804545 E 347.7791049737
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000000000
VPI 3 S 2089.9999886954 E 334.8635758091 L 449.9999976248
VPI 4 S 2475.0000000000 E 350.9044291061 L 309.9999999998
VPI 5 S 3220.0000000000 E 355.8885049737 L 350.0000000000
VPI 6 S 3625.4654804545 E 347.7791049737
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1625.0000000000 E 348.7335323853 L 100.0000000000
VPI 3 S 1800.0000000000 E 350.4102498541 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6640391459 L 80.0000000001
VPI 5 S 2085.0000000000 E 352.8665391459 L 80.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 92.9219649306
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1625.0000000000 E 348.7335323853 L 100.0000000000
VPI 3 S 1800.0000000000 E 350.4102498541 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6640391459 L 79.9999999997
VPI 5 S 2105.0000000000 E 352.9965391459 L 130.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 99.8947999724
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1575.0000000000 E 348.1126447308 L 100.0000000000
VPI 3 S 1750.0000000000 E 349.9337472941 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6500000000 L 81.1242489294
VPI 5 S 2105.0000000000 E 352.9825000000 L 130.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1575.0000000000 E 348.1126447308 L 100.0000000000
VPI 3 S 1750.0000000000 E 349.9337472941 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6500000000 L 81.1242489294
VPI 5 S 2105.0000000000 E 352.9825000000 L 130.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1575.0000000000 E 348.1126447308 L 100.0000000000
VPI 3 S 1750.0000000000 E 349.9337472941 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6500000000 L 81.1242489294
VPI 5 S 2105.0000000000 E 352.9825000000 L 130.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.0000000000
VPI 4 S 2475.0000000000 E 350.5010049737 L 310.0000000000
VPI 5 S 3225.0000000000 E 355.7885049737 L 350.0000000000
VPI 6 S 3625.4654804545 E 347.7791049737
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.0000000000
VPI 4 S 2475.0000000000 E 350.5010049737 L 310.0000000000
VPI 5 S 3225.0000000000 E 355.7885049737 L 350.0000000000
VPI 6 S 3655.1499999999 E 347.1854078826
END PROFILE
STORE PROFILE Y1
VPI 1 S 1500.0000000000 E 347.1813132492
VPI 2 S 1575.0000000000 E 348.1126447308 L 100.0000000000
VPI 3 S 1750.0000000000 E 349.9337472941 L 100.0000000000
VPI 4 S 1900.0000000000 E 351.6500000000 L 80.0000000000
VPI 5 S 2105.0000000000 E 352.9825000000 L 130.0000000000
VPI 6 S 2450.0000000000 E 350.1412105672 L 100.0000000000
VPI 7 S 2500.0000000000 E 350.3073664726
END PROFILE
STORE PROFILE Y2
VPI 1 S 1200.0000000000 E 351.7096893615
VPI 2 S 1675.0000000000 E 348.6929000292 L 100.0041457609
VPI 3 S 1805.0000000000 E 347.2625323007 L 150.0000000000
VPI 4 S 2100.0000000000 E 348.1500000000 L 250.0000000000
VPI 5 S 2515.0000000000 E 360.0501989547 L 370.0000000000
VPI 6 S 2700.0000000000 E 356.4611989547
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.3009413811
VPI 4 S 2475.0000000000 E 350.5127499999 L 310.7435057578
VPI 5 S 3220.0000000000 E 355.7277499999 L 349.9179719318
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.0000000000
VPI 4 S 2475.0000000000 E 350.5127499999 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.7277499999 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1545.0000000000 E 337.5885762801 L 370.0000008853
VPI 3 S 2090.0000000000 E 334.8635758091 L 450.0000000000
VPI 4 S 2475.0000000000 E 350.5127499999 L 310.0000000000
VPI 5 S 3220.0000000000 E 355.7277499999 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE Y_NORTH
VPI 1 S 1275.0000000000 E 330.9313970857
VPI 2 S 1287.9899869116 E 331.1911968239 L 9.8159106747
VPI 3 S 1321.6699999999 E 334.0425917566
VPI 4 S 1345.0000000000 E 335.9089917566 L 14.6204756797
VPI 5 S 1370.0000000000 E 336.6589917566
END PROFILE
