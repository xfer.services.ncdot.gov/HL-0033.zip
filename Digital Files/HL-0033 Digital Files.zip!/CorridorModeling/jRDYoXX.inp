STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1880.0000000000 E 321.3903678082 L 710.0000000000
VPI 3 S 2475.0000000000 E 350.5127499999 L 360.0000000000
VPI 4 S 3220.0000000000 E 355.7277499999 L 350.0000000000
VPI 5 S 3599.1399999999 E 348.1283110376
VPI 6 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE Y_SOUTH
VPI 1 S 1025.0000000000 E 329.7535737257
VPI 2 S 1039.9999999998 E 329.9335737257 L 29.9999999996
VPI 3 S 1145.0000000000 E 333.4771582528 L 60.0000000000
VPI 4 S 1196.3999999999 E 332.4491582528
END PROFILE
STORE PROFILE Y_SOUTH
VPI 1 S 1021.0300000000 E 329.7229710347
VPI 2 S 1025.0000000000 E 329.7535737257
VPI 3 S 1040.0000000000 E 329.9185737257 L 30.0000000000
VPI 4 S 1145.0000000000 E 333.4771582528 L 60.0000000000
VPI 5 S 1196.3999999999 E 332.4491582528
END PROFILE
STORE PROFILE Y_SOUTH
VPI 1 S 1025.0000000000 E 329.7535737257
VPI 2 S 1039.9999999998 E 329.9335737257 L 29.9999999996
VPI 3 S 1145.0000000000 E 333.4771582528 L 60.0000000000
VPI 4 S 1196.3999999999 E 332.4491582528
END PROFILE
STORE PROFILE L
VPI 1 S 1000.0000000000 E 267.9552598523
VPI 2 S 1165.0000000000 E 263.7673792607 L 230.0000000000
VPI 3 S 1470.0000000000 E 248.0000000000 L 380.0000000000
VPI 4 S 2175.0000000000 E 244.2915194451 L 390.0000000000
VPI 5 S 2375.0000000000 E 252.8957274534
END PROFILE
STORE PROFILE Y_DET
VPI 1 S 1138.0500000000 E 333.0673321630
VPI 2 S 1138.4700000000 E 333.0736462025
VPI 3 S 1160.0000000000 E 333.3971391105 L 40.0000000000
VPI 4 S 1300.0000000000 E 328.2000000000 L 120.0000000000
VPI 5 S 1410.0000000000 E 336.8200256259 L 53.0000000000
VPI 6 S 1436.8999999999 E 336.9007256259
END PROFILE
STORE PROFILE Y_DET2
VPI 1 S 1138.0500000000 E 333.0673321630
VPI 2 S 1138.4700000000 E 333.0736462025
VPI 3 S 1160.0000000000 E 333.3971391105 L 40.0000000000
VPI 4 S 1300.0000000000 E 328.2000000000 L 120.0000000000
VPI 5 S 1410.0000000000 E 336.8200256259 L 53.0000000000
VPI 6 S 1436.8999999999 E 336.9007256259
END PROFILE
STORE PROFILE Y_DET2
VPI 1 S 1138.8799999999 E 333.0769702136
VPI 2 S 1165.0000000000 E 333.4729366714 L 52.0000000000
VPI 3 S 1270.0000000000 E 327.5000000000 L 130.0000000000
VPI 4 S 1400.0000000000 E 336.8244656142 L 50.0000000000
VPI 5 S 1425.4199999999 E 336.9007256142
END PROFILE
STORE PROFILE Y_DET2
VPI 1 S 1138.8799999999 E 333.0769702136
VPI 2 S 1165.0000000000 E 333.4729366714 L 52.0000000000
VPI 3 S 1270.0000000000 E 327.5000000000 L 130.0000000000
VPI 4 S 1400.0000000000 E 336.8244656142 L 50.0000000000
VPI 5 S 1425.4199999999 E 336.9007256142
END PROFILE
