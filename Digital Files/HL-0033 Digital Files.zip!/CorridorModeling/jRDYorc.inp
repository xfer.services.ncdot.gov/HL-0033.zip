STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1735.0000000000 E 328.1573678083 L 429.9999999999
VPI 3 S 2140.0000000000 E 334.7733500000 L 310.0000000000
VPI 4 S 2475.0000000000 E 350.5173450000 L 360.0000000000
VPI 5 S 3220.0000000000 E 355.7300000000 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1735.0000000000 E 328.1573678083 L 429.9999999999
VPI 3 S 2140.0000000000 E 334.7733500000 L 310.0000000000
VPI 4 S 2475.0000000000 E 350.5173450000 L 360.0000000000
VPI 5 S 3220.0000000000 E 355.7300000000 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE L
VPI 1 S 1360.0000000000 E 346.5323678083
VPI 2 S 1735.0000000000 E 328.1573678083 L 429.9999999998
VPI 3 S 2140.0000000000 E 334.7685946614 L 310.0000000000
VPI 4 S 2475.0000000000 E 350.5127499999 L 360.0000000000
VPI 5 S 3220.0000000000 E 355.7277499999 L 350.0000000000
VPI 6 S 3599.1399999999 E 348.1283110376
VPI 7 S 3655.1499999999 E 347.0081110376
END PROFILE
STORE PROFILE Y_NORTH
VPI 1 S 1275.0000000000 E 330.9313970857
VPI 2 S 1287.9900000000 E 331.1911968239 L 15.0000000000
VPI 3 S 1345.0000000002 E 335.8945218239 L 12.9878782344
VPI 4 S 1370.0000000000 E 336.8746986377
END PROFILE
STORE PROFILE Y_NORTH
VPI 1 S 1269.3999999999 E 330.8211773739
VPI 2 S 1310.0000000000 E 331.6331714299 L 60.0000000000
VPI 3 S 1380.0000000000 E 336.8509448841 L 40.0000000000
VPI 4 S 1400.0000000000 E 336.9109448841
END PROFILE
STORE PROFILE Y_NORTH
VPI 1 S 1269.3999999999 E 330.8211773739
VPI 2 S 1310.0000000000 E 331.6331714299 L 60.0000000000
VPI 3 S 1380.0000000000 E 336.8509448841 L 40.0000000000
VPI 4 S 1400.0000000000 E 336.9109448841
END PROFILE
STORE PROFILE Y_SOUTH
VPI 1 S 1025.0000000000 E 329.7535737257
VPI 2 S 1040.0000000000 E 329.8890096871
VPI 3 S 1155.0000000000 E 333.2771582528
VPI 4 S 1196.3999999999 E 332.4491582528
END PROFILE
STORE PROFILE Y_SOUTH
VPI 1 S 1025.0000000000 E 329.7535737257
VPI 2 S 1040.0000000000 E 329.8890096871 L 30.0000000000
VPI 3 S 1155.0000000000 E 333.2771582528 L 50.0000000000
VPI 4 S 1196.3999999999 E 332.4491582528
END PROFILE
